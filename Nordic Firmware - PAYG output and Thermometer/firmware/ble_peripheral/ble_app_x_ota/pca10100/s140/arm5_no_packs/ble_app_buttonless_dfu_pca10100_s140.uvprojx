# Keil uVision project ble_app_buttonless_dfu_pca10100_s140.uvprojx, settings and files
target nrf52833_xxaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x00800000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52833_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: SSL_FL APP_TIMER_V2 _WIN32 APP_TIMER_V2_RTC1_ENABLED BL_SETTINGS_ACCESS_ONLY BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52833_XXAA NRF52_PAN_74 NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\thedotfactory_fonts;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\components\drivers_ext\ili9341;..\..\..\..\..\..\components\drivers_ext\st7735;..\..\..;..\..\..\..\Sources;..\config;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_link_ctx_manager;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\external\nexus\include;..\..\..\..\..\..\external\nexus;..\..\..\..\..\..\external\nexus\src;..\..\..\..\..\..\external\nexus\utils;..\..\..\..\..\..\external\nexus\examples\BLE\inc;..\..\..\..\Sources\FL_Specific
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BL_SETTINGS_ACCESS_ONLY BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52833_XXAA NRF52_PAN_74 NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBL_SETTINGS_ACCESS_ONLY,-DBOARD_PCA10100,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52833_XXAA,-DNRF52_PAN_74,-DNRF_DFU_SVCI_ENABLED,-DNRF_DFU_TRANSPORT_BLE=1,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0x40000
  memory RVCT9: RAM 0x20002f00 size 0x1d100
  memory RVCT10: RAM 0x800000 size 0x20000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
    ../../../../Sources/: ssl_config.h ssl_global_variables.h ble_device_config_service.c ble_flash_fstorage_definitions.c ble_gpio_config.c ble_pue_use_update_service.c ble_pwr_mgmt_definitions.c ble_resource_definitions.c ble_timers_definitions.c cbor_definitions.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group nRF_BLE
    ../../../../../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_DFU
    ../../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c nrf_drv_uart.c
    ../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_spi.c nrfx_spim.c nrfx_gpiote.c nrfx_rtc.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Drivers_External
    ../../../../../../components/drivers_ext/st7735/: st7735.c
    ../../../../../../components/drivers_ext/ili9341/: ili9341.c
  group nRF_External
    ../../../../../../external/thedotfactory_fonts/: calibri.c orkney8pts.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/gfx/: nrf_gfx.c
    ../../../../../../components/libraries/uart/: retarget.c app_uart_fifo.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_SVC
    ../../../../../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nexus
    ../../../../../../external/nexus/utils/: crc_ccitt.c siphash_24.c
    ../../../../../../external/nexus/src/: nexus_util.c nexus_security.c nexus_common_internal.c nexus_keycode_pro.c nexus_keycode_core.c nexus_keycode_mas.c nexus_nv.c nexus_keycode_pro_extended.c
    ../../../../../../external/nexus/examples/BLE/src/: feedback.c clock.c payg_state.c identity.c keycode.c processing.c screen.c
target flash_s140_nrf52_7.2.0_softdevice (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s140_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x800000 size 0x20000
  link misc: --diag_suppress 6330
target s140_nrf52833_xxaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: nrf52833_xxaa_s140 +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BL_SETTINGS_ACCESS_ONLY BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52833_XXAA NRF52_PAN_74 NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\thedotfactory_fonts;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\components\drivers_ext\ili9341;..\..\..\..\..\..\components\drivers_ext\st7735;..\..\..;..\..\..\Sources;..\config;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_link_ctx_manager;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\ble\ble_services\ble_lbs
  asm define: as above
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBL_SETTINGS_ACCESS_ONLY,-DBOARD_PCA10100,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52833_XXAA,-DNRF52_PAN_74,-DNRF_DFU_SVCI_ENABLED,-DNRF_DFU_TRANSPORT_BLE=1,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x52000
  memory RVCT9: RAM 0x20002418 size 0xdbf0
  memory RVCT10: RAM 0x800000 size 0x20000
  link misc: --diag_suppress 6330
target s140_nrf52833_xxaa_debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: nrf52833_xxaa_S140 +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: as above
  c misc: --reduce_paths
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x52000
  memory RVCT9: RAM 0x20002418 size 0xdbf0
  memory RVCT10: RAM 0x800000 size 0x20000
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, CMSIS:CORE 5.5.0, Device:Startup 8.35.0
